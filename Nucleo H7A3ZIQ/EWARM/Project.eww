<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo H7A3ZIQ.ewp</path>
  </project>
  <batchBuild />
</workspace>
