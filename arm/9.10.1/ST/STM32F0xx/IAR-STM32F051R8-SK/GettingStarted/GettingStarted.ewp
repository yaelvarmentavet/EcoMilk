# IAR project GettingStarted.ewp, settings and files
configuration IAR-STM32F051R8-SK (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072R8 ST STM32F072R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_IAR_STM32F0XX_KSK; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\Utilities\IAR_STM32F0xx_KSK; ..\Utilities\IAR_STM32F0xx_KSK\HD44780_Framework; ..\Utilities\IAR_STM32F0xx_KSK\Acc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ./: system_stm32f0xx.c
  group Doc
    ./: readme.txt
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group IAR-STM32F0xx-SK
    ../Utilities/IAR_STM32F0xx_KSK/: i2c2_drv.c stm320Fxx_ksk.c
  group IAR-STM32F0xx-SK/Acc
    ../Utilities/IAR_STM32F0xx_KSK/Acc/: accl_drv.c
  group IAR-STM32F0xx-SK/LCD
    ../Utilities/IAR_STM32F0xx_KSK/HD44780_Framework/: drv_hd44780.c drv_hd44780_l.c
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ./: main.c stm32f0xx_it.c
